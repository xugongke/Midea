<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8S005k6_Library.ewp</path>
  </project>
  <batchBuild/>
</workspace>


