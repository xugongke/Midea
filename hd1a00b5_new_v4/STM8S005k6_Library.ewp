# IAR project STM8S005k6_Library.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x160
  General.GenHeapSize: 0x10
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ; APP\inc; STM8S_StdPeriph_Driver\src; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S005k6_Library.hex
  ILINK.IlinkOutputFile: STM8S005k6_Library.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP/inc
    APP/inc/: board.h gpio_cfg.h key.h motor_ctrl.h para.h stm8s_conf.h stm8s_it.h
  group APP/src
    APP/src/: burned.c gpio_init.c key.c main.c para.c stm8s_it.c
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
