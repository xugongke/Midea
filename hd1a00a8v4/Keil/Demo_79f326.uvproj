# Keil uVision project Demo_79f326.uvproj, settings and files
target ADC (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_ADC +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: ADC_TEST
  c include: ..\Include
  group TIMER
    ../Source/Timer/: Timer3.c Timer4.c Timer5.c Timer_Test.c
  group LCD
    ../Source/Lcd/: Lcd.c Lcd_Test.c
  group PCA
    ../Source/Pca/: Pca0.c Pca0_Test.c
  group TWI
    ../Source/Twi/: Twi.c Twi_Test.c
  group UART
    ../Source/Uart/: Uart.c Uart_Test.c
  group PWM
    ../Source/PWM/: PWM.c PWM_Test.c
  group LPD
    ../Source/LPD/: LPD_Test.c
  group EEPROM
    ../Source/Eeprom/: Eeprom.c Eeprom_Test.c
  group SYSTEM
    ../Source/Sys/: system.c
  group ISR
    ../Source/Isr/: interrupt.c
  group MAIN
    ../Source/Main/: main.c myiic.c tk_cfg.c tk_328_12Key_Pdata_V1.2.LIB dis.c tk_debug.c
  group CRC
    ../Source/CRC/: CRC.c CRC_Test.c
target SYSCLK (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_SYSCLK +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: Enable_sysclk_test
  c include: ..\Include
target TIMER (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_TIMER +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: Timer_test
  c include: ..\Include
target LCD (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_LCD +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: LCD_TEST
  c include: ..\Include
target LED (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_LED +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: LED_TEST
  c include: ..\Include
target PCA (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_PCA +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: PCA0_Test
  c include: ..\Include
target TWI (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_TWI +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: TWI_TEST
  c include: ..\Include
target EUART (MCS-51)
  device: SH79F328 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x4FF) CLOCK(24000000)
  output: Demo_79f326_EUART +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: Enable_uart_test
  c include: ..\Include
target PWM (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_PWM +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: PWM_TEST
  c include: ..\Include
target LPD (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_LPD +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: LPD_TEST
  c include: ..\Include
target EEPROM (MCS-51)
  device: SH79F326 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x4FF) CLOCK(24000000)
  output: Demo_79f326_E2PROM +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: EEPROM_TEST
  c include: ..\Include
target CRC (MCS-51)
  device: SH79F083 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: Demo_79f326_LED +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: CRC_TEST
  c include: ..\Include
